# IAR project DEMO.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S103K3U STM8S103K3U
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCIncludePath2: ..; ..\Libraries\STM8S_StdPeriph_Driver\inc; ..\App; ..\BSP; ..\Cfg
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: ENCODER.hex
  ILINK.IlinkOutputFile: DEMO.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group APP
    ../APP/: encoder.c ILI9163.c ILI9163.h main.c SGP18T_ILI9163B_ascii.c SGP18T_ILI9163B_base.h SGP18T_ILI9163B_figure.c show.c stm8s_conf.h stm8s_it.c stm8s_it.h
    ./: ILI9163CHN.c ILI9163CHN.h
  group Libraries/STM8S_StdPeriph_Driver
    ../Libraries/STM8S_StdPeriph_Driver/src/: stm8s_adc1.c stm8s_adc2.c stm8s_awu.c stm8s_beep.c stm8s_can.c stm8s_clk.c stm8s_exti.c stm8s_flash.c stm8s_gpio.c stm8s_i2c.c stm8s_itc.c stm8s_iwdg.c stm8s_rst.c stm8s_spi.c stm8s_tim1.c stm8s_tim2.c stm8s_tim3.c stm8s_tim4.c stm8s_tim5.c stm8s_tim6.c stm8s_uart1.c stm8s_uart2.c stm8s_uart3.c stm8s_wwdg.c
